# Keil uVision project boot.uvprojx, settings and files
target bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: bootloader
  AfterMake: fromelf --bin !L --output bootloader.bin
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: UNO_81A_U04 OTA_LAMZ_COMPRESS_SUPPORT
  c include: ./hal/rda;./bootloader;./bootloader/hw/rda5981;./hal/rda/device/rda5981
  library: MicroLIB
  memory RVCT1: ROM 0x18001000 size 0x5000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x180000 size 0x20000
  group bootloader
    ./bootloader/: bootloader.c crc32.c firmware.c image.c bootloader_ping_pong.c bootloader_triple_area.c bootloader_copy.c
    ./bootloader/hw/rda5981/: flash.c flash_layout.c
  group main
    ./main/: main.c retarget.c
  group HAL
    ./hal/rda/: board.c drv_uart.c rda_api.c
    ./hal/rda/device/rda5981/: system_rda5981.c
    ./hal/rda/device/TOOLCHAIN_ARM_STD/: startup_rda5981.s
  group lzma
    ./lzma/lib/: lzma.lib
